## boards/shields/chocofi_dongle/Kconfig.shield
```kconfig
config SHIELD_CHOCOFI_DONGLE
    def_bool $(shields_list_contains,chocofi_dongle)
```
